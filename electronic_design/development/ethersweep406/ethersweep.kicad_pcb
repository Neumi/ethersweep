# Repository Neumi/ethersweep (continued)

## KiCad design electronic_design/ethersweep/ethersweep.kicad_pcb

Parts:
C1, C6, C9, C12, C19, C20, C21, C22, C23, C27: C100nF; C_0805_2012Metric; LCSC C49678
C2: C4.7uF; C_1206_3216Metric; LCSC C29823
C3: C1nF; C_1206_3216Metric; LCSC C35216
C4: C22nF; C_0603_1608Metric; LCSC C21122
C5, C35: C10nF; C_0603_1608Metric; LCSC C57112
C7, C13: C6.8nF; C_0603_1608Metric; LCSC C1542
C8, C10: C22pF; C_0402_1005Metric; LCSC C1555
C11: C0.22uF; C_0805_2012Metric; LCSC C5378
C14, C15, C16, C17, C24, C25: C100nF; C_0402_1005Metric; LCSC C1525
C18: C22nF; C_0805_2012Metric; LCSC C1729
C26, C30: C10uF; C_0805_2012Metric; LCSC C15850
C29: C100nF; C_0805_2012Metric; LCSC C1525
C33, C34: C18pF; C_0402_1005Metric; LCSC C1549
C36: C4.7uF; C_0402_1005Metric; LCSC C23733
D1, D2: LED; LED_0603_1608Metric; LCSC C84256
D3, D4: LED; LED_0603_1608Metric; LCSC C2297
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J8: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
J2: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal; LCSC C431092
J3: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Vertical
J4, J5: Conn_01x02_Male; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal; LCSC C225424
J6: Conn_01x07_Female; PinHeader_1x07_P2.54mm_Vertical
J7: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J9: USB_B_Micro; USB_Micro-B_Molex_47346-0001; LCSC C132560
J10: HR911105A; HANRUN_HR911105A; PARTREV A; LCSC C12074
J11: Conn_01x04_Male; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
L1: L600OHM; L_0805_2012Metric; LCSC C1017
R1, R2, R3, R16: R10k; R_0603_1608Metric; LCSC C25804
R4, R5, R6, R7: R33; R_0805_2012Metric; LCSC C17634
R8: R10; R_0805_2012Metric; LCSC C17415
R9, R10, R18, R23: R49.9; R_0603_1608Metric; LCSC C23185
R11, R12: R180mOHM; R_1206_3216Metric; LCSC C159408
R13, R19, R20, R24, R25, R26: R330; R_0603_1608Metric; LCSC C23138
R14, R15, R17: R1k; R_0603_1608Metric; LCSC C21190
R21: R1M; R_0603_1608Metric; LCSC C17514
R22: R12K4; R_0603_1608Metric; LCSC C30908
RV1: R_POT_20K; Potentiometer_Bourns_TC33X_Vertical; LCSC C719177
SW1: SW_Push; SW_Push_SPST_NO_Alps_SKRK; LCSC C720477
TP1, TP2, TP3, TP4: TestPoint; TestPoint_Pad_D2.0mm
U1: CP2102N-A01-GQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C6568
U2: ATmega328-AU; TQFP-32_7x7mm_P0.8mm; LCSC C14877
U3: TMC2208-LA-T; TQFN-28-1EP_5x5mm_P0.5mm_EP3.25x3.25mm_ThermalVias; PARTREV 1.09; LCSC C115944
U4: DD4012SA
U5: AS5600
U6: W5500; LQFP-48_7x7mm_P0.5mm
Y2: Crystal_25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006
Y3: Crystal; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C14.1, C15.1, C16.1, C17.1, C24.1, C25.1, C26.1, L1.2, R8.1, R9.1, R10.1, U6.4 (AVDD), U6.8 (AVDD), U6.11 (AVDD), U6.15 (AVDD), U6.17 (AVDD), U6.21 (AVDD)
+3V3: C1.1, C12.2, C29.1, C30.1, J1.2 (VCC), J3.2, J8.2 (VCC), J10.9, J10.12, L1.1, R1.1, R2.1, R3.1, R13.1, R14.1, R15.1, RV1.1, TP1.1, U2.4 (VCC), U2.6 (VCC), U2.18 (AVCC), U2.20 (AREF), U3.15 (VCC_IO), U4.3 (VOUT), U5.1 (VDD5V), U5.2 (VDD3V3), U5.8 (DIR), U6.28 (VDD), U6.43 (PMODE2), U6.44 (PMODE1), U6.45 (PMODE0)
+12V: C2.1, C6.1, C9.2, C22.1, C23.1, J2.2, R16.1, U3.22 (VS), U3.28 (VS), U4.1 (VIN)
CS_ETHERNET: J6.5, J7.5, U2.14 (PB2), U6.32 (~SCS)
DIR: U2.10 (PD6), U3.19 (DIR)
ENDSTOP: J5.2, J6.2, J7.2, R2.2, U2.1 (PD3)
ESTOP: J4.2, J6.1, J7.1, R1.2, U2.2 (PD4)
ETHERNET_LED_A: J10.11, R19.1
ETHERNET_LED_B: J10.10, R20.1
ETH_INT: J6.7, J7.7, U2.12 (PB0), U6.36 (~INT)
FLT_STEPPER: U2.26 (PC3), U3.12 (INDEX)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C8.2, C10.1, C11.2, C12.1, C14.2, C15.2, C16.2, C17.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C29.2, C30.2, C33.1, C34.2, C35.2, C36.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, J1.6 (GND), J2.1, J3.1, J4.1, J5.1, J8.6 (GND), J9.5 (GND), J9.6 (Shield), R11.2, R12.2, R17.2, R22.1, RV1.3, SW1.2, TP2.1, U1.3 (GND), U1.29 (GND), U2.3 (GND), U2.5 (GND), U2.21 (GND), U3.3 (GND), U3.7 (NC), U3.13 (CLK), U3.14 (PDN_UART), U3.18 (GND), U3.20 (NC), U3.25 (NC), U3.29 (EP), U4.2 (GND), U5.4 (GND), U6.3 (AGND), U6.9 (AGND), U6.14 (AGND), U6.16 (AGND), U6.19 (AGND), U6.29 (GND), U6.48 (AGND), Y2.2, Y2.4
GND1: C3.1, J10.8, J10.15 (SHIELD), J10.16 (SHIELD)
M0: U2.24 (PC1), U3.9 (MS1)
M1: U2.23 (PC0), U3.10 (MS2)
M2: U2.25 (PC2), U3.11 (DIAG)
MISO: J1.1 (MISO), J8.1 (MISO), U2.16 (PB4), U6.34 (MISO)
MOSI: J1.4 (MOSI), J8.4 (MOSI), U2.15 (PB3), U6.35 (MOSI)
unnamed: C7.2, R6.1, R18.2
unnamed: C8.1, U2.7 (XTAL1/PB6), Y3.2
unnamed: C9.1, U3.6 (VCP)
unnamed: C10.2, U2.8 (XTAL2/PB7), Y3.1
unnamed: C11.1, U3.8 (5VOUT)
unnamed: C13.2, R7.1, R23.2
unnamed: C18.1, U3.4 (CPO)
unnamed: C18.2, U3.5 (CPI)
unnamed: C20.1, U1.6 (VDD)
unnamed: C21.1, J9.1 (VBUS), U1.7 (REGIN), U1.8 (VBUS)
unnamed: C27.2, U1.28 (~DTR)
unnamed: C33.2, R21.1, U6.30 (XI/CLKIN), Y2.3
unnamed: C34.1, R21.2, U6.31 (XO), Y2.1
unnamed: C35.1, U6.22 (1V2O)
unnamed: C36.1, U6.20 (TOCAP)
unnamed: D1.2 (A), R13.2
unnamed: D2.2 (A), R24.2
unnamed: D3.2 (A), R25.2
unnamed: D4.2 (A), R26.2
unnamed: J9.2 (D-), U1.5 (D-)
unnamed: J9.3 (D+), U1.4 (D+)
unnamed: J11.1, U3.21 (OA2)
unnamed: J11.2, U3.26 (OB1)
unnamed: J11.3, U3.24 (OA1)
unnamed: J11.4, U3.1 (OB2)
unnamed: R4.2, U6.1 (TXN)
unnamed: R5.2, U6.2 (TXP)
unnamed: R6.2, U6.5 (RXN)
unnamed: R7.2, U6.6 (RXP)
unnamed: R11.1, U3.23 (BRA)
unnamed: R12.1, U3.27 (BRB)
unnamed: R19.2, U6.25 (LINKLED)
unnamed: R20.2, U6.27 (ACTLED)
unnamed: R22.2, U6.10 (EXRES1)
unnamed: R24.1, U2.32 (PD2)
unnamed: R25.1, U6.24 (SPDLED)
unnamed: R26.1, U6.26 (DUPLED)
unnamed: RV1.2, U3.17 (VREF)
RC: C5.2, J10.5, R18.1, R23.1
RD+: C13.1, J10.3
RD-: C7.1, J10.6
RST_ETHERNET: J6.6, J7.6, U2.13 (PB1), U6.37 (~RST)
SCK: J1.3 (SCK), J8.3 (SCK), U2.17 (PB5), U6.33 (SCLK)
SCL: J3.3, J6.3, J7.3, R14.2, U2.28 (PC5), U5.7 (SCL)
SDA: J3.4, J6.4, J7.4, R15.2, U2.27 (PC4), U5.6 (SDA)
STEP: U2.11 (PD7), U3.16 (STEP)
STEPPER_ENABLE: U2.9 (PD5), U3.2 (ENN)
TC: C4.2, J10.4, R8.2
TD+: J10.1, R5.1, R10.2
TD-: J10.2, R4.1, R9.2
rst: C27.1, J1.5 (~RST), J8.5 (~RST), R3.2, SW1.1, U2.29 (~RESET/PC6)
uC_RX: TP3.1, U1.26 (TXD), U2.30 (PD0)
uC_TX: TP4.1, U1.25 (RXD), U2.31 (PD1)
voltage_detect: C19.1, R16.2, R17.1, U2.19 (ADC6)

Notes on the sheet:
up to 36.3V without destroying a328p 0,035V resolution with 10Bit ADC
OLED
PCB Bridge

Board: 2 copper layers, 79.0 x 38.0 mm, 97 parts (9 on the bottom side), 72 nets.

File electronic_design/ethersweep/ethersweep_BOM_301.csv:

Comment,Designator,Footprint,LCSC
"C0.22uF","C11","Capacitor_SMD:C_0805_2012Metric","C5378"
"C100nF","C1,C6,C9,C12,C19,C22,C23","Capacitor_SMD:C_0805_2012Metric","C49678"
"C100nF","C14,C15,C16,C17,C24,C25","Capacitor_SMD:C_0402_1005Metric","C1525"
"C22nF","C18","Capacitor_SMD:C_0805_2012Metric","C1729"
"C4.7uF","C2","Capacitor_SMD:C_1206_3216Metric","C29823"
"C100uF","C20","Capacitor_SMD:CP_Elec_8x10","C176665"
"C1nF","C3","Resistor_SMD:R_1206_3216Metric","C35216"
"C10uF","C26,C30","Capacitor_SMD:C_0805_2012Metric","C15850"
"C18pF","C33,C34","Capacitor_SMD:C_0402_1005Metric","C1549"
"C10nF","C5,C35","Capacitor_SMD:C_0603_1608Metric"," C57112"
"C4.7uF","C36","Capacitor_SMD:C_0402_1005Metric"," C23733"
"C22nF","C4","Resistor_SMD:R_0603_1608Metric","C21122"
"C6.8nF","C7,C13","Capacitor_SMD:C_0603_1608Metric","C1631"
"C22pF","C8,C10","Capacitor_SMD:C_0402_1005Metric","C1555"
"LED","D1,D2,D3,D4","LED_SMD:LED_0603_1608Metric","C2286"
"MountingHole_Pad","H1,H2,H3,H4,H5,H6,H7,H8","MountingHole:MountingHole_3.2mm_M3_Pad_Via",""
"AVR-ISP-6","J1,J8","Connector_IDC:IDC-Header_2x03_P2.54mm_Vertical",""
"HR911105A","J10","modules:HANRUN_HR911105A","C12074"
"Conn_01x02_Male","J2","Connector_AMASS:AMASS_XT30PW-M_1x02_P2.50mm_Horizontal","C431092"
"Conn_01x04_Female","J3","Connector_PinHeader_2.54mm:PinHeader_1x04_P2.54mm_Vertical",""
"Conn_01x02_Male","J4,J5","Connector_JST:JST_EH_S2B-EH_1x02_P2.50mm_Horizontal","C225424"
"Conn_01x07_Female","J6","Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical",""
"Conn_01x07_Male","J7","Connector_PinHeader_2.54mm:PinHeader_1x07_P2.54mm_Vertical",""
"L600OHM","L1","Inductor_SMD:L_0805_2012Metric","C1017"
"Stepper_Motor_bipolar","M1","Connector_PinHeader_2.54mm:PinHeader_2x02_P2.54mm_Vertical_SMD",""
"R10k","R1,R2,R3,R16","Resistor_SMD:R_0603_1608Metric","C25804"
"R49.9","R9,R10,R18,R23","Resistor_SMD:R_0603_1608Metric","C23185"
"R180mOHM","R11,R12","Resistor_SMD:R_1206_3216Metric","C159408"
"R330","R13,R19,R20,R24,R25,R26","Resistor_SMD:R_0603_1608Metric","C23138"
"R1k","R14,R15,R17","Resistor_SMD:R_0603_1608Metric","C21190"
"R1M","R21","Resistor_SMD:R_0603_1608Metric","C17514"
"R12K4","R22","Resistor_SMD:R_0603_1608Metric","C30908"
"R33","R4,R5,R6,R7","Resistor_SMD:R_0805_2012Metric","C17634"
"R10","R8","Resistor_SMD:R_0805_2012Metric","C17415"
"R_POT_20K","RV1","Potentiometer_THT:Potentiometer_Bourns_3296W_Vertical",""
"SW_Push","SW1","Button_Switch_SMD:SW_Push_SPST_NO_Alps_SKRK","C720477"
"TestPoint","TP1,RX1,TX1,TP2","TestPoint:TestPoint_Pad_D2.0mm",""
"Pololu_D24V3F3","U1","Module:Pololu_D24V3F3",""
"ATmega328-AU","U2","Package_QFP:TQFP-32_7x7mm_P0.8mm","C14877"
"TMC2208-LA-T","U3","Package_DFN_QFN:TQFN-28-1EP_5x5mm_P0.5mm_EP3.25x3.25mm_ThermalVias","C115944"
"AS5600","U5","modules:AS5600",""
"W5500","U6","Package_QFP:LQFP-48_7x7mm_P0.5mm",""
"Crystal_25MHz","Y2","Crystal:Crystal_SMD_3225-4Pin_3.2x2.5mm","C9006"
"Crystal","Y3","Crystal:Crystal_SMD_5032-2Pin_5.0x3.2mm","C115962"

## KiCad design electronic_design/prototype/ethersweep.kicad_pcb

Parts:
A1: Pololu_Breakout_DRV8825; Pololu_Breakout-16_15.2x20.3mm
B1: ARDUINO_PRO_MINI
C1_100uF1, C1_100uF2: CP; CP_Radial_D8.0mm_P3.80mm
C2_1uF1, C2_1uF2: CP; CP_Radial_D5.0mm_P2.50mm
C100nF1: C; C_1206_HandSoldering
D1: WS2812B; LED_WS2812B-PLCC4
H1, H2, H3: Mount; MountingHole_3.5mm_Pad_Via
J1: Jack-DC; Barrel_Jack_CUI_PJ-036AH-SMT
J2: ETH_LEFT; Pin_Header_Straight_1x08_Pitch2.54mm
J3: ETH_RIGHT; Pin_Header_Straight_1x08_Pitch2.54mm
J5: Conn_01x04_Female; Pin_Header_Straight_1x04_Pitch2.54mm
M1: Stepper_Motor_bipolar; Pin_Header_Straight_1x04_Pitch2.54mm
R1.66k1, R5k1: R; R_0805_HandSoldering

Connections:
+5V: B1.21 (VCC), C1_100uF1.1, C2_1uF1.1, C100nF1.1, D1.1 (VDD), J2.1, J2.2, J5.2
GND: A1.1 (GND), A1.7 (GND), B1.23 (GND@2), C1_100uF1.2, C1_100uF2.2, C2_1uF1.2, C2_1uF2.2, C100nF1.2, D1.3 (VSS), H1.1, H2.1, H3.1, J1.2, J2.3, J2.4, J2.5, J2.6, J5.1, R1.66k1.2
unnamed: A1.3 (A2), M1.1
unnamed: A1.4 (A1), M1.2 (-)
unnamed: A1.5 (B1), M1.3
unnamed: A1.6 (B2), M1.4
unnamed: A1.9 (~EN), B1.10 (7)
unnamed: A1.13 (~RST), B1.12 (*9)
unnamed: A1.14 (~SLP), B1.11 (8)
unnamed: A1.15 (STEP), B1.9 (*6)
unnamed: A1.16 (DIR), B1.8 (*5)
unnamed: B1.7 (4), D1.4 (DIN)
unnamed: B1.13 (*10), J3.7
unnamed: B1.14 (*11), J3.5
unnamed: B1.15 (12), J3.4
unnamed: B1.16 (13), J3.6
unnamed: B1.A7, R1.66k1.1, R5k1.2
SCL: B1.A5, J5.3
SDA: B1.A4, J5.4
VCC: A1.8 (VMOT), B1.24 (RAW), C1_100uF2.1, C2_1uF2.1, J1.1, R5k1.1
analog0: A1.2 (~FLT), B1.17 (A0)
analog1: A1.12 (M2), B1.18 (A1)
analog2: A1.11 (M1), B1.19 (A2)
analog3: A1.10 (M0), B1.20 (A3)

Board: 2 copper layers, 60.0 x 60.0 mm, 18 parts (0 on the bottom side), 24 nets.

## Code that names these connections

File code/ethersweep_STM32_450/src/Configuration.h:

#pragma once

const String version = "3.5.2"; // software version

#define STATIC_IP 1 // when set 1, DHCP is enabled, when 0, statis IP is used

#define DEBUG_MODE 1 // when set 1, debugging output is enabled

#define BAUD_SPEED 9600 // debug and message baud speed

#define SYS_VOL 3.3 // system voltage in volts

#define OLED_I2C_ADDRESS 0x3C // i2c address of oled display

#define BUFFER_SIZE 256 // communication buffer size

#define LOCAL_PORT 8888 // local UDP port

#define STANDARD_REMOTE_SENSOR_PORT 5000 // remote machines receiving UDP port

#define DEFAULT_DISPLAY_REFRESH_TIME 100 // milliseconds until new data is shown
#define DEFAULT_FEEDBACK_TIME 300 // milliseconds until hearbeat

// action definitions
#define STEPS 0      // runs certain ammounts of steps
#define HOME 1       // homes until endstop is reached
#define RAMP 2       // ramps motor with certain slope
#define POWERCYCLE 3 // power cycles motor controller
#define POSITION 4   // encoder feedback position loop
#define SENSORFEEDBACK 5 // sends sensor values to IP and PORT
#define HEARTBEAT 6 // sends heartbeat answer values to IP and PORT
#define IDENTIFY 7 // sends IDENTIFY answer values to IP and PORT
#define CONFIGURE 8 // receives and saves configuration data

// scheduler modes
#define standby 0 // waiting for instructions
#define running 1 // running drive loop

// W5500 ethernet chip
#define SLEEP_PIN PB0 // ethernet int
#define RESET_PIN PA1 // ethernet reset
#define CS_PIN PB9 // ethernet chip select

// TMC2209 motor controller chip
#define ENABLE_PIN PB8
#define STEP_PIN PB15
#define DIR_PIN PA8
#define M0_PIN PB4 // MS1
#define M1_PIN PB3 // MS2
#define DIAG_PIN PA15
#define FAULT_PIN PA14

// sensor inputs
#define VOLT_DETECT_PIN PB1
#define END_STOP_PIN PA3
#define E_STOP_PIN PA4
#define RANDOM_SEED_PIN PA2

// outputs
#define LED_PIN PC13

// connection modes
#define CONNECTION_STAT "STAT"
#define CONNECTION_DHCP "DHCP"
#define CONNECTION_USB "USB "
 

File getting_started/code_for_testing_v450/motor_test/motor_test.ino:

#include <TMCStepper.h> // TMCstepper - https://github.com/teemuatlut/TMCStepper
// FOR ETHERSWEEP Hardware v4.5.0 with STM32 controller and TMC2209
// running this code should spin the stepper motor on Ethersweep in different speeds and directions.
// the interface happens through serial2 and does not need STOP DIR pins
// this only works on Ethersweep v4.5.0

#define MS1_PIN  PB4
#define MS2_PIN  PB3
#define EN_PIN PB8
HardwareSerial Serial2(PB11, PB10);

#define DRIVER_ADDRESS 0x00 // TMC2209 driver address when MS1 LOW and MS2 LOW
#define R_SENSE 0.1f // TMC2209 with 100mOhm R shunt
bool dir = false;

// SoftwareSerial SoftSerial(PB11, PB10);
TMC2209Stepper TMCdriverX(&Serial2, R_SENSE, DRIVER_ADDRESS);

void setup() {
  Serial2.begin(115200);
  TMCdriverX.beginSerial(115200);

  pinMode(EN_PIN, OUTPUT);
  pinMode(MS2_PIN, OUTPUT);
  pinMode(MS1_PIN, OUTPUT);

  digitalWrite(EN_PIN, LOW);
  digitalWrite(MS1_PIN, LOW);
  digitalWrite(MS2_PIN, LOW);

  TMCdriverX.begin();
  TMCdriverX.toff(5);
  TMCdriverX.rms_current(500); // motor current in mA
  TMCdriverX.microsteps(64); // microsteps in 1/x
  TMCdriverX.en_spreadCycle(false);
  TMCdriverX.pwm_autoscale(true); // needed for stealthChop
  TMCdriverX.VACTUAL(12000); // motor speed
  TMCdriverX.step();
}

void loop() {
  delay(100);
  dir = !dir;
  TMCdriverX.shaft(dir);

  delay(500);
  TMCdriverX.VACTUAL(50000);

  delay(500);
  dir = !dir;
  TMCdriverX.shaft(dir);
  delay(500);

  TMCdriverX.VACTUAL(12000);
  delay(200);
  for (int i = 0; i <= 20; i++) {
    dir = !dir;
    TMCdriverX.shaft(dir);
    delay(50);
  }
}

## Commit log

2020-04-13 added initial
2020-05-11 changes with light
2020-05-11 added python code
2020-05-11 Update README.md
    changed readme
2020-06-24 Update README.md
    added video link
2020-06-24 added gif
2020-07-04 added i2c oled display support
2020-07-05 removed unused skp files
2020-07-10 added i2c display support
2020-07-12 removed reversed step timing. now input equals delay in microseconds between step
2021-05-27 design changes
2021-11-09 added 304 version
2021-11-09 removed deprecated files
2021-11-09 Update README.md
    changed images
2022-03-23 added 3d cad files, production files, for 3.0.4
2022-04-10 minor electronics changes, DHCP standard enabled, display optimizations, speed improvements in main loop, display refresh only with empty ethernet buffer
2022-07-25 current version, dhcp standard enabled, fast display refresh,
2022-07-25 added python code and flask application
2022-07-25 removed unneeded code
2022-07-25 removed old arduino code
2022-07-25 removed old code + design files
2022-07-25 removed skp file
2022-07-25 file name changed
2022-07-25 removed old file
2022-07-25 Update README.md
    temp version
2022-07-26 added 3d files and documentation images
2022-07-26 added display image
2022-07-26 added overview image
2022-07-26 changed name
2022-07-26 changed side image
2022-07-26 changed image
2022-07-26 changed image name
2022-07-26 removed old electronics design
2022-08-31 added serial debug option (memroy impact decrease)
2022-08-31 added working static + dhcp option
2022-08-31 static / DHCP display added
2022-09-02 added automatic mac generation and eeprom storage
2022-09-02 added automatic mac generation and eeprom stroage fixed
2022-09-02 added / fixed power cycle. strange problem with random step mode changes occoured. probable ram issue
2022-09-05 added servo feature test
2022-09-06 added ramping feature.
2022-09-06 added flask zip
2022-09-07 added image
2022-09-09 added license
2022-09-09 styling
2022-09-14 background invert bug fixes #5
2022-09-14 correcting conversion factor for angle fixs #4
2022-09-14 angle and voltage display corrected fixes #6
2022-09-15 added display description
2022-09-15 Update README.md
    changed display description image size
2022-09-15 changed display description
2022-09-16 Create FUNDING.yml
    added funding button
2022-09-16 added basic USB support
2022-09-16 added version number
2022-09-16 styling, simplified voltage calculation
2022-09-20 changed angle calculation. removed fixed constant
2022-09-20 added arduinojson version comment
2022-09-21 added arduino json version 6 support
2022-09-27 changed version name in head
2022-09-29 usb mode bug fix when no LAN cable is connected
2022-09-29 frontend changes in flask app and ip address display
2022-09-29 display changes for ip address
2022-09-29 flask changes
2022-09-29 added flask app update and fixed version problems
2022-09-29 changed pinout for nema17 motor to be parallel to connector
2022-10-16 minor changes
2022-11-18 added OOP code, platformio config and project. Major refactoring done
2022-11-20 minor bug fixes, cleanup, restructuring
2022-12-12 added test, unity setup and config and some minor changes
2022-12-12 first changes for stm32 and tmc2209 transfer
2022-12-13 added hardware tests
2022-12-13 added gitignore
2022-12-13 backup cleanup
2022-12-15 refactoring, cleanup
2022-12-15 clearnup, refactoring
2023-01-10 major commit for ethersweep 4 with STM32 MCU and USB C + fixes
2023-01-11 cleanup, schmeatic design around USB connecotr, STM32 and reorganisation
2023-01-12 layout version 4 in manufacturable state: STM32, TMC2209, USBC, 3 pin switches
2023-01-16 minor design changes
2023-01-24 pcb design changes, reorganisation, JLC part number assignments, size corrections
2023-01-24 added production data
2023-01-24 part assignments, minor part changes
2023-01-25 minor
2023-01-25 added images and example code
2023-01-25 added images
2023-01-25 Delete top_v4.png
    rm file
2023-01-25 Update README.md
    readme images changed
2023-02-08 added 3d files for v4
2023-02-08 added logo
2023-02-08 format change
2023-03-08 board fixes for 402 version
2023-03-08 added 402 version
2023-03-08 added development and production
2023-03-08 cleanup
2023-03-08 added readme fiels
2023-03-08 added readmes
2023-04-06 Update README.md
    added news note
2023-05-24 added version 405 files for tmc2209 version with micro usb and CP2102 chip. production ready
2023-06-06 added getting started initial. plus code to test the TMC2209 via serial2 on the STM32
2023-06-06 Update README.md
    added instructions to gettings started
2023-06-06 added board setting images
2023-06-06 Update README.md
    added image to readme
2023-06-06 changed image size
2023-06-07 added code for stm32 version for hardware 4.5
2023-06-07 Update README.md
    added news for stm32 version
2023-08-17 added latest production and development version
2023-08-17 removed old production
2023-08-17 changed description in readme
2023-08-24 added as5600 example code with absolute position
2023-08-24 changed stepmode config for tmc2209 for version 405
2023-09-14 added sponsoring banner
2023-09-14 Update README.md
    added sponsoring banner
2023-09-18 added CAN development board
2023-09-18 added receive script
2023-09-18 added sensor feedback mode, refactoring
2023-09-19 changed voltage to millivolts
2023-09-20 Update README.md
    updated readme
2023-10-22 added weekly robotics sponsor
2023-10-24 added heartbeat mode
2023-10-25 added identify mode and minor changes
2023-10-25 cleanup in software dir
2023-10-25 more cleanup in code dir
2023-10-25 removed ds_store
2023-10-25 added basic python interface function tests back
2023-10-25 readme style changes
2023-10-25 minor code and docu changes
2023-10-25 cleanup 3d files
2023-10-25 removed outdated examples
2023-10-25 cleanup examples
2023-10-25 removed old stl file
2023-10-25 removed old backup files
2023-10-25 removed 405 version from development dir
2023-10-25 cleanup and minor design changes in 406
2023-10-25 cleanup final
2023-10-26 minor cleanup
2023-11-13 added dynamic configuration concept
2023-11-14 work backup
2023-11-21 initial message processor and experiments around w5500 hardware interrupt handling
2023-11-23 dev stage
2023-11-27 Update README.md
    added google from for user research
2023-12-11 staging changes
2024-02-26 added 360 degree angle tracking and zero cossing detection
