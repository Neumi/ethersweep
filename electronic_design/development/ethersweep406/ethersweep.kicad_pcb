# Repository Neumi/ethersweep

File README.md:

# Ethersweep
### An Open Source Ethernet controllable stepper motor. Easy interfacing with JSON and UDP from any device on the network in any language you choose.

Want to stay updated or participate? Join my [Discord](https://discord.com/invite/rerCyqAcrw)!

*As there is quite some interest in buying a controller, please fill out this form to help me better understand what Ethersweep would be used for https://forms.gle/FLgfvCP1hjCCp2636*

More media/press material:
https://drive.google.com/drive/folders/1qrk8QeEkzJ8hkr-H0x3y7xxhLTKhMb_F?usp=share_link

> *NEWS NOTE:*  Ethersweep is a project still in development. If you plan to order boards for yourself, you can, but expect it to take some work to get everything running! If you have any questions, please write me on Discord: https://discord.com/invite/rerCyqAcrw or
LinkedIn: https://www.linkedin.com/in/neumi/
If you need a custom assembly code or have a special use case in mind, contact me.
The latest running version is in the [production](electronic_design/production) directory. It is now an STM32f103 version with TMC2209 stepper driver. The assembly files contain LCSC part numbers and can be directly ordered at JLCPCB including assembly. Only some THT parts and SMD AS5600 encoder must be soldered by hand.

## What it does
Ethersweep is a motor controller for NEMA17 stepper motors that can be controlled from normal Ethernet networks. This means that you will be able to control motion from normal computers (laptop/server/raspberrypi), mobile devices, microcontrollers, PLCs and any other machine that is capable of sending UDP messages. On top you can control as many motors as you like because every motor gets an IP address from the DHCP server on your network.
You can also connect End and E-Stops to the controller. Sensor data like encoder feedback, voltage, running and button states can also be requested via network requests.

All you need is a network and power between 5v and 30v.

## What it needs
Every motor has to be connected to an Ethernet network (optimally with DHCP) and a power supply between 5...30V. USB can be used for programming the controller with new firmware. End and E-Stops can be connected with JST3-pin connectors. To send instructions to Ethersweep you just send a JSON-encoded message via UDP to the controller's IP and port.

## Features:
- W5500 Ethernet controller
- STM32f103 Microcontroller @ 72MHz
- Trinamic TMC2209 Stepper motor driver
- AS5600 magnetic rotary encoder
- XT30 power connector
- Oled 128x32 Display
- USB programmable
- Inputs for E-Stop and End-Stop
- Reset button
- Fits on a NEMA17 stepper motor
- standard RJ45 network connector

## How to get started:
Build an (or multiple) Ethersweep controller. All manufacturing/assembly files work with JLCPCB and only some easy THT soldering is needed when the boards arrive. The code is available in the repository.

Connect your Ethersweep controller to your network via ethernet and connect to a 5.5...30V power source. Stick an encoder magnet (radial magnetized) on a NEMA17 motor shaft and connect the controller to the four M3 screws of the motor.
Once connected to power and Ethernet, it searches for an IP address using DHCP. When an IP is found, the controller shows it on the display and it's ready to use. When no IP is found, it defaults to 192.168.1.111 if available. (It is recommended to use DHCP)

Now you can use the Python script to control the motor.

## Using Python to control a stepper motor:

```python
import socket
import json

IP_MOTOR = "192.168.1.185" # ethersweep IP (change to motors IP)
UDP_PORT = 8888 # ethersweep port

def drive_motor(steps, speed, direction, mode, motor_ip):
    json_data = json.dumps({'steps': steps, 'speed': speed, 'direction': direction, 'mode': mode})
    message = json_data.encode()
    sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
    sock.sendto(message, (motor_ip, UDP_PORT))

drive_motor(100, 9500, 1, 32, IP_MOTOR) # this will spin the motor 100 steps
```

## Video:

Follow the project on hackaday.io: https://hackaday.io/project/187187-ethersweep

## Upcoming Features:
- [ ] improved Broadcast mode + motor synchronization for multiple motors
- [ ] motor servo mode
- [ ] TMC2209 software interface
- [ ] scheduler

## Big thanks to the sponsors of this project!

## KiCad design electronic_design/development/ethersweep406/ethersweep.kicad_pcb

File electronic_design/development/ethersweep406/readme.md:

# Version 4.5.0

Added CP2102 with STM32f103 and micro USB on a four layer board.
Sent to manufacturing on 24.05.2023

Parts:
C1, C6, C23, C27, C38: C100nF; C_0603_1608Metric; LCSC C14663
C2: C4.7uF; C_1206_3216Metric; LCSC C29823
C3: C1nF; C_1206_3216Metric; LCSC C35216
C4: C22nF; C_0603_1608Metric; LCSC C21122
C5: C10nF; C_0603_1608Metric; LCSC C57112
C7, C13: C6.8nF; C_0402_1005Metric; LCSC C1542
C8, C10: C22pF; C_0402_1005Metric; LCSC C1555
C9: C22nF 50V; C_0402_1005Metric; LCSC C1532
C11: C2.2-4.7uF ceramic; C_1206_3216Metric; LCSC C29823
C12, C14, C15, C16, C17, C18, C19, C20, C21, C22, C29, C32, C37, C41, C42: C100nF; C_0402_1005Metric; LCSC C307331
C26, C30: C10uF; C_0805_2012Metric; LCSC C15850
C31, C40: C10uF; C_1206_3216Metric; LCSC C13585
C33, C34: C18pF; C_0402_1005Metric; LCSC C1549
C35: C10nF; C_0402_1005Metric; LCSC C15195
C36: C4.7uF; C_0402_1005Metric; LCSC C23733
C39: C_330uF; CP_Elec_10x10; LCSC C249985
D1, D2: LED; LED_0603_1608Metric; LCSC C2286
D3, D4: LED; LED_0603_1608Metric; LCSC C2296
D5: D_TVS_5V; D_SOD-123; LCSC C478011
D6: D_TVS_30V; D_SOD-123; LCSC C553410
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1, J8: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
J2: Conn_01x02_Male; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal; LCSC C431092
J3: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Vertical
J4, J5: Conn_01x03_Male; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J6: Conn_01x07_Female; PinHeader_1x07_P2.54mm_Vertical
J7: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J9: Conn_01x04_Female; JST_EH_S4B-EH_1x04_P2.50mm_Horizontal
J10: HR911105A; HANRUN_HR911105A; PARTREV A; LCSC C12074
J11: USB_B_Micro; USB_Micro-AB_Molex_47590-0001; LCSC C136001
L1: L600OHM; L_0805_2012Metric; LCSC C1017
R1, R2: R10k; R_0603_1608Metric; LCSC C25804
R3, R16, R24, R27, R28, R29: R10k; R_0402_1005Metric; LCSC C25744
R4, R5, R6, R7: R33; R_0603_1608Metric; LCSC C23140
R8: R10; R_0603_1608Metric; LCSC C22859
R9, R10, R18, R23: R49.9; R_0603_1608Metric; LCSC C23185
R11, R12: R100mOHM; R_2010_5025Metric; LCSC C175979
R13, R19, R20, R25, R26: R330; R_0603_1608Metric; LCSC C23138
R14, R21: R1M; R_0402_1005Metric; LCSC C26083
R15: R1k; R_0603_1608Metric; LCSC C21190
R17, R30: R1k; R_0402_1005Metric; LCSC C11702
R22: R12K4; R_0603_1608Metric; LCSC C234268
SW1: SW_Push; SW_SPST_B3U-3000P; LCSC C963349
TP1: 3.3V; TestPoint_Pad_D2.0mm
TP2: GND; TestPoint_Pad_D2.0mm
TP3: RX; TestPoint_Pad_D2.0mm
TP4: TX; TestPoint_Pad_D2.0mm
TP5: BOOT_1; TestPoint_Pad_D2.0mm
TP6: BOOT_0; TestPoint_Pad_D2.0mm
U2: CP2102N-A01-GQFN28; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm; LCSC C6568
U3: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm; LCSC C8734
U4: DD4012SA
U5: AS5600
U6: W5500; LQFP-48_7x7mm_P0.5mm; LCSC C32843
U7: TMC2209-LA; LCSC C465949
Y2: Crystal_25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C9006
Y3: Crystal; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3.3VA: C15.1, C16.1, C17.1, C18.1, C20.1, C21.1, C26.1, L1.2, R8.1, R9.1, R10.1, U6.4 (AVDD), U6.8 (AVDD), U6.11 (AVDD), U6.15 (AVDD), U6.17 (AVDD), U6.21 (AVDD)
+3V3: C1.1, C12.2, C14.1, C19.1, C30.1, C32.1, C37.1, C38.1, J1.2 (VCC), J3.2, J4.2, J5.2, J8.2 (VCC), J10.9, J10.12, L1.1, R1.1, R2.1, R3.1, R13.1, R24.1, R27.1, TP1.1, U3.9 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U4.3 (VOUT), U5.1 (VDD5V), U5.2 (VDD3V3), U5.8 (DIR), U6.28 (VDD), U6.43 (PMODE2), U6.44 (PMODE1), U6.45 (PMODE0), U7.15 (VCC_IO); also elsewhere on the board
+28V: C2.1, C6.1, C23.1, C27.1, C31.1, C39.1, C40.1, D6.1 (K), J2.2, R16.1, U4.1 (VIN), U7.22 (VS), U7.28 (VS)
BOOT_0: R29.2, TP6.1, U3.44 (BOOT0); also elsewhere on the board
BOOT_1: R28.2, TP5.1, U3.20 (PB2)
CS: J6.7, J7.7, U3.46 (PB9), U6.32 (~SCS)
ENDSTOP: J4.3, J6.2, J7.2, R1.2, U3.13 (PA3)
ESTOP: J5.3, J6.1, J7.1, R2.2, U3.14 (PA4)
ETHERNET_LED_A: J10.11, R19.1
ETHERNET_LED_B: J10.10, R20.1
ETH_INT: J6.6, J7.6, U3.18 (PB0), U6.36 (~INT)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.2, C8.2, C10.1, C11.2, C12.1, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.1, C26.2, C27.2, C29.1, C30.2, C31.2, C32.2, C33.1, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.2 (A), D6.2 (A), H1.1, H2.1, H3.1, H4.1, H5.1, H6.1, H7.1, H8.1, J1.6 (GND), J2.1, J3.1, J4.1, J5.1, J8.6 (GND), J11.5 (GND), R11.1, R12.1, R17.2, R22.1, R28.1, R29.1, SW1.2, TP2.1, U2.3 (GND), U2.29 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.2 (GND), U5.4 (GND), U6.3 (AGND), U6.9 (AGND), U6.14 (AGND), U6.16 (AGND), U6.19 (AGND), U6.29 (GND), U6.48 (AGND), U7.3 (GND), U7.13 (CLK)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
GND1: C3.1, J10.8, J10.15 (SHIELD), J10.16 (SHIELD)
MISO: J1.1 (MISO), J8.1 (MISO), U3.16 (PA6), U6.34 (MISO)
MOSI: J1.4 (MOSI), J8.4 (MOSI), U3.17 (PA7), U6.35 (MOSI)
MOT_DIAG: U3.38 (PA15), U7.11 (DIAG)
MOT_DIR: U3.29 (PA8), U7.19 (DIR)
MOT_ENABLE: U3.45 (PB8), U7.2 (ENN)
MOT_INDEX: U3.37 (PA14), U7.12 (INDEX)
MOT_M0: U3.40 (PB4), U7.9 (MS1_AD0)
MOT_M1: U3.39 (PB3), U7.10 (MS2_AD1)
MOT_SPREAD: U3.41 (PB5), U7.7 (SPREAD)
MOT_STANDBY: U3.27 (PB14), U7.20 (STDBY)
MOT_STEP: U3.28 (PB15), U7.16 (STEP)
MOT_UART_RX: R30.2, U3.21 (PB10), U7.14 (PDN_UART)
MOT_UART_TX: R30.1, U3.22 (PB11)
unnamed: C7.2, R6.1, R18.2
unnamed: C13.2, R7.1, R23.2
unnamed: D1.2 (A), R13.2
unnamed: D2.2 (A), R15.1
unnamed: D3.2 (A), R25.2
unnamed: D4.2 (A), R26.2
unnamed: C11.1, D5.1 (K), U7.8 (5VOUT)
unnamed: J9.1, U7.1 (OB2)
unnamed: J9.2, U7.26 (OB1)
unnamed: J9.3, U7.24 (OA1)
unnamed: J9.4, U7.21 (OA2)
unnamed: J11.3 (D+), U2.4 (D+)
unnamed: J11.2 (D-), U2.5 (D-)
unnamed: C41.2, J11.1 (VBUS), U2.7 (REGIN), U2.8 (VBUS)
unnamed: C29.2, U2.6 (VDD)
unnamed: C42.2, U2.28 (~DTR)
unnamed: R15.2, U3.2 (PC13-TAMPER-RTC)
unnamed: C10.2, R14.1, U3.5 (PD0-OSC_IN), Y3.1
unnamed: C8.1, R14.2, U3.6 (PD0-OSC_OUT), Y3.2
unnamed: C35.1, U6.22 (1V2O)
unnamed: R20.2, U6.27 (ACTLED)
unnamed: R26.1, U6.26 (DUPLED)
unnamed: R22.2, U6.10 (EXRES1)
unnamed: R19.2, U6.25 (LINKLED)
unnamed: R6.2, U6.5 (RXN)
unnamed: R7.2, U6.6 (RXP)
unnamed: R25.1, U6.24 (SPDLED)
unnamed: C36.1, U6.20 (TOCAP)
unnamed: R4.2, U6.1 (TXN)
unnamed: R5.2, U6.2 (TXP)
unnamed: C33.2, R21.1, U6.30 (XI/CLKIN), Y2.3
unnamed: C34.1, R21.2, U6.31 (XO), Y2.1
unnamed: R12.2, U7.23 (BRA)
unnamed: R11.2, U7.27 (BRB)
unnamed: C9.2, U7.5 (CPI)
unnamed: C9.1, U7.4 (CPO)
unnamed: C23.2, U7.6 (VCP)
RC: C5.2, J10.5, R18.1, R23.1
RD+: C13.1, J10.3
RD-: C7.1, J10.6
RST_ETHERNET: J6.5, J7.5, U3.11 (PA1), U6.37 (~RST)
SCK: J1.3 (SCK), J8.3 (SCK), U3.15 (PA5), U6.33 (SCLK)
SCL: J3.3, J6.3, J7.3, R24.2, U3.42 (PB6), U5.7 (SCL)
SDA: J3.4, J6.4, J7.4, R27.2, U3.43 (PB7), U5.6 (SDA)
TC: C4.2, J10.4, R8.2
TD+: J10.1, R5.1, R10.2
TD-: J10.2, R4.1, R9.2
rst: C22.2, C42.1, J1.5 (~RST), J8.5 (~RST), R3.2, SW1.1, U3.7 (NRST)
uC_RX: TP3.1, U2.26 (TXD), U3.31 (PA10)
uC_TX: TP4.1, U2.25 (RXD), U3.30 (PA9)
voltage_detect: R16.2, R17.1, U3.19 (PB1)

Notes on the sheet:
USB
W5500 Ethernet Controller
M3 mounts
OLED
End and Emergency Stop
Power input and regulation
PCB Bridge Connectorboard
ENCODER
TMC2209 Motor Controller
Debug connectors
Pull UPs Downs
STM32 Microcontroller
up to 36.3V without destroying STM32F103c8 0,0886V resolution with 12Bit ADC when aREF 3.3V
Reset Button
PCB Bridge Mainboard

Board: 4 copper layers, 79.0 x 38.0 mm, 111 parts (9 on the bottom side), 77 nets.

Other parts of the board:
SW2: SW_BOOT_0; SW_SPST_B3U-3000P

Their connections:
+3V3: SW2.1; also elsewhere on the board
BOOT_0: SW2.2; also elsewhere on the board

## KiCad design electronic_design/development/ethersweep407_CAN/ethersweep.kicad_pcb

File electronic_design/development/ethersweep407_CAN/readme.md:

# Version 4.6.0

Current development files.

Board: 4 copper layers, 38.0 x 38.0 mm, 24 parts (3 on the bottom side), 20 nets.

Parts:
C1, C3: C22pF; C_0402_1005Metric
C4, C5: C100nF; C_0402_1005Metric
H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J3: Conn_01x04_Female; PinHeader_1x04_P2.54mm_Vertical
J4, J5: Conn_01x03_Male; JST_EH_S3B-EH_1x03_P2.50mm_Horizontal
J7: Conn_01x07_Male; PinHeader_1x07_P2.54mm_Vertical
J8: AVR-ISP-6; IDC-Header_2x03_P2.54mm_Vertical
J10: CAN_BUS; TerminalBlock_Altech_AK300-2_P5.00mm
JP1: CAN_TERMINATION; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2: R10k; R_0603_1608Metric
R4: R120; R_0603_1608Metric
R5: R1M; R_0402_1005Metric
R6: R10k; R_0402_1005Metric
SW1: SW_Push; SW_SPST_B3U-3000P
U1: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U6: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
Y1: Crystal; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C4.1, C5.1, J3.2, J4.2, J5.2, J8.2 (VCC), R1.1, R2.1, R6.2, U1.20 (VDD), U6.3 (VCC)
CS: J7.7, U1.18 (~CS)
ENDSTOP: J4.3, J7.2, R1.2
ESTOP: J5.3, J7.1, R2.2
ETH_INT: J7.6, U1.13 (~INT)
GND: C1.1, C3.2, C4.2, C5.2, H5.1, H6.1, H7.1, H8.1, J3.1, J4.1, J5.1, J8.6 (GND), SW1.2, U1.10 (VSS), U6.2 (GND)
MISO: J8.1 (MISO), U1.17 (SO)
MOSI: J8.4 (MOSI), U1.16 (SI)
unnamed: J10.1, R4.2, U6.7 (CANH)
unnamed: J10.2, JP1.1 (A), U6.6 (CANL)
unnamed: JP1.2 (B), R4.1
unnamed: C3.1, R5.2, U1.9 (OSC1), Y1.2
unnamed: C1.2, R5.1, U1.8 (OSC2), Y1.1
unnamed: U1.2 (RXCAN), U6.4 (RXD)
unnamed: U1.1 (TXCAN), U6.1 (TXD)
unnamed: R6.1, U1.19 (~RESET)
SCK: J8.3 (SCK), U1.14 (SCK)
SCL: J3.3, J7.3
SDA: J3.4, J7.4
rst: J8.5 (~RST), SW1.1

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
